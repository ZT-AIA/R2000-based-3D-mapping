# Keil uVision project Discovery.uvproj, settings and files
target Discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__CORTEX_M4F,__FPU_PRESENT,__CMSIS_RTOS
  c include: ..\inc;..\src;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4x7_ETH_Driver\inc;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\libraries\STM32F4-Discovery;..\..\libraries\lwip-1.4.1\port\STM32F4x7;..\..\libraries\lwip-1.4.1\src\include;..\..\libraries\lwip-1.4.1\src\include\ipv4;..\..\libraries\lwip-1.4.1\src\include\lwip;..\..\libraries\lwip-1.4.1\src\include\netif;..\..\libraries\lwip-1.4.1\port\STM32F4x7\arch;..\..\libraries\rtx-v4.73\INC;..\..\libraries\rtx-v4.73\SRC;..\..\libraries\ptpd-2.0.0\src;..\inc\system;..\inc\laser;..\inc\motorCtrl;..\..\libraries\lwip-1.4.1\src\include\ipv4\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: main.c system_stm32f4xx.c stm32f4xx_it.c netconf.c telnet.c shell.c stm32f4x7_eth_bsp.c timeStamp.c laserCloud.c navigation.c
    ../src/motroCtrl/: motorctrl.c
    ../src/laser/: dev.c
  group PTPD
    ../../libraries/ptpd-2.0.0/src/: arith.c bmc.c protocol.c ptpd.c
    ../../libraries/ptpd-2.0.0/src/dep/: msg.c net.c servo.c startup.c sys_time.c timer.c
  group LWIP
    ../../libraries/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../libraries/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../libraries/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c pbuf.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../libraries/lwip-1.4.1/src/netif/: etharp.c slipif.c
    ../../libraries/lwip-1.4.1/port/STM32F4x7/arch/: ethernetif.c sys_arch.c
  group RTX Configuration
    ../src/: RTX_Conf_CM.c
  group RTX Kernel
    ../../libraries/rtx-v4.73/SRC/: rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c
  group RTX HAL
    ../../libraries/rtx-v4.73/SRC/ARM/: SVC_Table.s HAL_CM4.c
    ../../libraries/rtx-v4.73/SRC/: HAL_CM.c
  group STM32F4-Discovery
    ../../libraries/STM32F4-Discovery/: stm32f4_discovery_lcd.c stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_tim.c
  group STM32F4x7_ETH_Driver
    ../../libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group Readme
    ../: readme.txt
  group system
    ../src/system/: system.c
